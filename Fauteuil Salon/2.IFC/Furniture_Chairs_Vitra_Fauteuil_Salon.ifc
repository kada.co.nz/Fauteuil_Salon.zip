Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:10:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:10:36 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{117CCB36-59D9-42B4-95DF-E0A6C6EA131B}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:10:35 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:10:35 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:10:35 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Fauteuil de Salon, Furniture_Chairs_Vitra_Fauteuil_Salon:Fauteuil de Salon:347363
In: Level 1
Type - Material: Leather standard dimgrey 21, Wood solid natural oak oiled 70, 12 deep black powder-coated (smooth), Glide black
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Fauteuil_Salon; ConvergoRefNr: 0089-2006-0010-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Developed by Jean Prouve, the Fauteuil de Salon is a typical example of the distinctive structural aesthetic of his designs. The armchair's understated character suits a wide variety of interiors, and its ample upholstery and oiled, solid wood armrests emanate inviting comfort.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Collection: Fauteuil; Cost: 0; Description: Developed by Jean Prouve, the Fauteuil de Salon is a typical example of the distinctive structural aesthetic of his designs. The armchair's understated character suits a wide variety of interiors, and its ample upholstery and oiled, solid wood armrests emanate inviting comfort.; Designer: Jean Prouve; Manufacturer: Vitra; Model: Fauteuil de Salon; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191331/storage/master/download/Factsheet%20Fauteuil%20De%20Salon-EN.pdf; Type Name: Fauteuil de Salon; URL: https://www.vitra.com/en-un/living/product/details/fauteuil-de-salon
Type - Materials and Finishes(Type) - ArmchairQuaternaryMaterial: Glide black
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Fauteuil_Salon; Features: Seat height: 415 mm (340 mm with applied load, measured in accordance with EN 1335-1).; Finish: Seat and backrest: polyurethane filling; cover in fabric or leather. Armrests: solid wood with oiled finish; natural oak, smoked oak or American walnut. Base: bent sheet steel and tubular steel, powder-coated (smooth). Glides: hard glides for carpet or felt glides for hard floors. Origin of wood: oak (Quercus robur) from Western Europe and/or Poland; American walnut (Juglans nigra) from the USA.; Grade: n/a; Material: Polyurethane, fabric or leather, wood & steel.; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Fauteuil_Salon; ReplacementCost: n/a; Shape: Sculptured; Size: 680x840x825 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.84061 m2; Volume: 0.476905 m3
Materials and Finishes - ArmchairMainMaterial: Leather standard dimgrey 21; ArmchairSecondaryMaterial: 12 deep black powder-coated (smooth); ArmchairTertiaryMaterial: Wood solid natural oak oiled 70
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Fauteuil_Salon: Fauteuil de Salon; Family and Type: Furniture_Chairs_Vitra_Fauteuil_Salon: Fauteuil de Salon; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Fauteuil_Salon: Fauteuil de Salon; Type Id: Furniture_Chairs_Vitra_Fauteuil_Salon: Fauteuil de Salon; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
